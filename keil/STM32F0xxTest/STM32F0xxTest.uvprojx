# Keil uVision project STM32F0xxTest.uvprojx, settings and files
target STM32F0xx (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F070F6Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00001800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stm32f0 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\General\StandardPeripheralDriver\Include;.\User\inc;.\General\CMSIS\ST\Include;.\General\CMSIS\Core\Include
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group User
    ./User/src/: main.c stm32f0xx_it.c
    ./User/inc/: main.h stm32f0xx_conf.h stm32f0xx_it.h
  group Startup
    ./General/Startup/: startup_stm32f0xx.s startup_stm32f0xx_ld.s startup_stm32f030.s startup_stm32f030xc.s startup_stm32f031.s startup_stm32f042.s startup_stm32f051.s startup_stm32f070x6.s startup_stm32f070xb.s startup_stm32f072.s startup_stm32f091.s
  group CMSIS
    ./General/CMSIS/ST/Source/: system_stm32f0xx.c
  group StdPeriph
    ./General/StandardPeripheralDriver/Source/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
